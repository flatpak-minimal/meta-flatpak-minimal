#
# Copyright (c) 2026 Contributors of meta-flatpak-minimal
#
# SPDX-License-Identifier: MIT
#
# libc++, which ivi-homescreen (flatpak-platform-runtime-image.bbappend) links.
LICENSE:append = " & Apache-2.0-with-LLVM-exception"
