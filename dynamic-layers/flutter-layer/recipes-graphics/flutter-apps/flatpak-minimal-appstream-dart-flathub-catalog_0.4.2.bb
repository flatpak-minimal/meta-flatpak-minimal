#
# Copyright (c) 2026 Contributors of meta-flatpak-minimal
# Copyright (c) 2026 Joel Winarske. All rights reserved.
# Copyright (c) 2026 Ahmed Wafdy. All rights reserved.
#
# SPDX-License-Identifier: MIT
#
SUMMARY = "flathub_catalog"
DESCRIPTION = "Flutter Linux desktop app demonstrating the appstream_dart package."
AUTHOR = "Joel Winarske"
HOMEPAGE = "https://github.com/flatpak-minimal/appstream_dart"
BUGTRACKER = "https://github.com/flatpak-minimal/appstream_dart/issues"
SECTION = "graphics"

LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=641bdc36389b26ea9787acb6844e4b22"

SRCREV = "486c103fe5a0accec2bba2b4952387e671c5691e"
SRC_URI = "gitsm://github.com/flatpak-minimal/appstream_dart.git;branch=main;protocol=https"

# appstream_core links sqlite3.
DEPENDS += "sqlite3"

FLUTTER_APPLICATION_PATH = "example/flathub_catalog"
PUBSPEC_APPNAME = "flathub_catalog"
FLUTTER_APPLICATION_INSTALL_SUFFIX = "appstream-dart-example-flathub-catalog"

inherit flutter-app-native flatpak-flutter-app

# Also packaged as a flatpak app on the Flutter runtime, in ${PN}-flatpak.
FLATPAK_APP_ID = "org.flatpak_minimal.appstream_dart.example.flathub_catalog"
# It reads the Flathub catalog over the network.
FLATPAK_APP_FINISH_ARGS = "--socket=wayland --device=dri --share=ipc --share=network"

# Vendored pub cache: dependencies arrive through SRC_URI with checksums
# rather than a networked `pub get` during the build. The .inc and the lockfile
# beside it are generated by meta-flutter's tools/pubvendor/pubvendor.py; see
# that repo's tools/pubvendor/README.md to regenerate them.
FILESEXTRAPATHS:prepend := "${THISDIR}:"
SRC_URI += "file://flatpak-minimal-appstream-dart-flathub-catalog-pubspec.lock"
require flatpak-minimal-appstream-dart-flathub-catalog-pubcache.inc
inherit pub-cache
PUBSPEC_APP_DIR = "${S}/${FLUTTER_APPLICATION_PATH}"
PUBSPEC_LOCK_FILE = "flatpak-minimal-appstream-dart-flathub-catalog-pubspec.lock"

# Configure the hook through meta-flutter; load Yocto's runtime directly.
RDEPENDS:${PN}:append = " libsqlite3"
FLUTTER_NATIVE_USER_DEFINES = '{"sqlite3": {"source": "system", "name": "${libdir}/libsqlite3.so.0"}}'

# pub-cache.bbclass orders do_seed_pub_cache only after do_unpack, but the task
# copies from the SDK in the recipe sysroot, which do_prepare_recipe_sysroot
# fills. On a cold build it can run first and fail with "no .pub-cache".
addtask seed_pub_cache after do_prepare_recipe_sysroot
