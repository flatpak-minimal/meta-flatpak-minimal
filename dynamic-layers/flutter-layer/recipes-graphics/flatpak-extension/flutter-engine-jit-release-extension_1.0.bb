#
# Copyright (c) 2026 Contributors of meta-flatpak-minimal
#
# SPDX-License-Identifier: MIT
#
FLUTTER_ENGINE_EXTENSION_MODE = "jit_release"

require flutter-engine-extension-bundle.inc
